# Keil uVision project STC51-DEMO.uvproj, settings and files
target STC51-DEMO (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: STC51-DEMO +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\USER;..\BSP
  link misc: REMOVEUNUSED
  group STARTUP
    ../STARTUP/: STARTUP.A51
  group USER
    ./: main.c
  group BSP
    ../BSP/: delay.c LED.c
